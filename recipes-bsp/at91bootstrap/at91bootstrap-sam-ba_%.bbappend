COMPATIBLE_MACHINE = "eink-extcon-demo"